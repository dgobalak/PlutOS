# Keil uVision project PlutOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tim
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __RTGT_UART
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./src/: Retarget.c uart.c _threadsCore.c _kernelCore.c svc_call.s _kernelCore.h osDefs.h main.c _timerCore.c _timerCore.h svc_handler.h svc_handler.c
    C:/Users/dgobalak/Desktop/PlutOS/src/: _threadsCore.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
